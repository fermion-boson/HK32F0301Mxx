# IAR project HK32F0301MxxC_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HK32F0301MF4P7C HSXP_HK HK32F0301MF4P7C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: HK32F0301MF4P7C; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\..\..\HK32F0301MxxC_Library\Lib\CMSIS\HK32F0301MxxC\Include; ..\..\..\..\HK32F0301MxxC_Library\Lib\HK32F0301MxxC_Lib\inc; ..\..\..\..\HK32F0301MxxC_Library\Lib\CMSIS\CM0\Core; ..\inc; ..\..\..\..\HK32F0301MxxC_Library\Lib\HK32F0301MxxC_Lib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HK32F0301MxxC_Demo.srec
  ILINK.IlinkOutputFile: HK32F0301MxxC_Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group CMSIS
    ../../../../HK32F0301MxxC_Library/Lib/CMSIS/HK32F0301MxxC/Source/IAR/: IAR_Sartup_hk32f0301mxxc.s
    ../../../../HK32F0301MxxC_Library/Lib/CMSIS/HK32F0301MxxC/Source/: system_hk32f0301mxxc.c
  group HK32F0301MxxC_Lib
    ../../../../HK32F0301MxxC_Library/Lib/HK32F0301MxxC_Lib/src/: hk32f0301mxxc_adc.c hk32f0301mxxc_awut.c hk32f0301mxxc_crc.c hk32f0301mxxc_dbgmcu.c hk32f0301mxxc_exti.c hk32f0301mxxc_flash.c hk32f0301mxxc_gpio.c hk32f0301mxxc_i2c.c hk32f0301mxxc_iwdg.c hk32f0301mxxc_mipi.c hk32f0301mxxc_misc.c hk32f0301mxxc_pwr.c hk32f0301mxxc_rcc.c hk32f0301mxxc_spi.c hk32f0301mxxc_syscfg.c hk32f0301mxxc_tim.c hk32f0301mxxc_uart.c
    ../../Lib/HK32F0301MxxC_Lib/src/: hk32f0301mxxc_wwdg.c
  group User
    ../src/: hk32f0301mxxc_it.c main.c
