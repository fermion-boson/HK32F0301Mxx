# Keil uVision project HK32F0301Mxxc_Demo.uvprojx, settings and files
target HK32F0301MxxC_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HK32F0301MF4P7C HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.15
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HK32F0301MxxC_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F0301MXXC, HK32F0301MF4P7C,MEM_REMAP
  c include: ..\..\HK32F0301MxxC_Library\Lib\HK32F0301MxxC_Lib\inc;..\..\HK32F0301MxxC_Library\Lib\CMSIS\HK32F0301MxxC\Include;..\inc;..\..\HK32F0301MxxC_Library\Lib\CMSIS\CM0\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000800 size 0x3800
  memory RVCT9: RAM 0x20000000 size 0x500
  scatter file: .\Objects\HK32F0301MxxC_Demo.sct
  group Start
    ../../HK32F0301MxxC_Library/Lib/CMSIS/HK32F0301MxxC/Source/ARM/: KEIL_Startup_hk32f0301mxxc.s
  group src
    ../src/: main.c hk32f0301mxxc_it.c
    ../../HK32F0301MxxC_Library/Lib/CMSIS/HK32F0301MxxC/Source/: system_hk32f0301mxxc.c
  group HK32F0301MxxC_lib
    ../../HK32F0301MxxC_Library/Lib/HK32F0301MxxC_Lib/src/: hk32f0301mxxc_adc.c hk32f0301mxxc_awut.c hk32f0301mxxc_crc.c hk32f0301mxxc_dbgmcu.c hk32f0301mxxc_exti.c hk32f0301mxxc_flash.c hk32f0301mxxc_gpio.c hk32f0301mxxc_i2c.c hk32f0301mxxc_iwdg.c hk32f0301mxxc_mipi.c hk32f0301mxxc_misc.c hk32f0301mxxc_pwr.c hk32f0301mxxc_rcc.c hk32f0301mxxc_spi.c hk32f0301mxxc_syscfg.c hk32f0301mxxc_tim.c hk32f0301mxxc_uart.c hk32f0301mxxc_wwdg.c
