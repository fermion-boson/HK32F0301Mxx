# Keil uVision project HK32F0301M_Demo.uvprojx, settings and files
target HK32F0301M_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030Mxx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HK32F0301M_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F0301M, HK32F0301MJ4M6,VECT_TAB_SRAM
  c include: ..\inc;..\..\..\HK32F0301M\HK32F0301M_Lib\inc;..\..\..\HK32F0301M\CMSIS\HK32F0301M\Include;..\..\..\HK32F0301M\CMSIS\CM0\Core
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x500
  memory RVCT9: RAM 0x20000500 size 0xb00
  scatter file: .\HK32F0301M_Demo.sct
  group Start
    ../../../HK32F0301M/CMSIS/HK32F0301M/Source/ARM/: Keil_Startup_hk32f0301m.s
  group src
    ../src/: main.c hk32f0301m_it.c
    ../../../HK32F0301M/CMSIS/HK32F0301M/Source/: system_hk32f0301m.c
  group HK32F0301M_lib
    ../../../HK32F0301M/HK32F0301M_Lib/src/: hk32f0301m_adc.c hk32f0301m_awu.c hk32f0301m_beep.c hk32f0301m_crc.c hk32f0301m_exti.c hk32f0301m_flash.c hk32f0301m_gpio.c hk32f0301m_i2c.c hk32f0301m_iwdg.c hk32f0301m_misc.c hk32f0301m_pwr.c hk32f0301m_rcc.c hk32f0301m_spi.c hk32f0301m_syscfg.c hk32f0301m_tim.c hk32f0301m_usart.c hk32f0301m_wwdg.c
