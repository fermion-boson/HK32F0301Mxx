# Keil uVision project IAP_Boot.uvprojx, settings and files
target Boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F0301MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F0301M_DFP.1.0.5
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Boot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F0301MF4P6
  c include: ..\source\device\inc;..\source\user;..\source\bsp;..\source\stdlib\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group device
    ../source/device/: Keil_Startup_hk32f0301m.s
  group user
    ../source/user/: main.c hk32f0301m_it.c system_hk32f0301m.c
  group bsp
    ../source/bsp/: bsp_system.c bsp_usart.c bsp_hk32f0301m_eval.c
  group stdlib
    ../source/stdlib/src/: hk32f0301m_adc.c hk32f0301m_awu.c hk32f0301m_beep.c hk32f0301m_crc.c hk32f0301m_dbgmcu.c hk32f0301m_exti.c hk32f0301m_flash.c hk32f0301m_gpio.c hk32f0301m_i2c.c hk32f0301m_iwdg.c hk32f0301m_misc.c hk32f0301m_pwr.c hk32f0301m_rcc.c hk32f0301m_spi.c hk32f0301m_syscfg.c hk32f0301m_tim.c hk32f0301m_usart.c hk32f0301m_wwdg.c
