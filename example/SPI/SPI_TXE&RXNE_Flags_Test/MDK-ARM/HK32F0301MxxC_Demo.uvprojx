# Keil uVision project HK32F0301MxxC_Demo.uvprojx, settings and files
target HK32F0301MxxC_Demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HK32F0301MF4P7C HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.15
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HK32F030XMXXA_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F0301MXXA , HK32F0301MF6P7A
  c include: ..\..\..\..\HK32F0301MxxC_Library\Lib\HK32F0301MxxC_Lib\inc;..\..\..\..\HK32F0301MxxC_Library\Lib\CMSIS\HK32F0301MxxC\Include;..\..\..\..\HK32F0301MxxC_Library\Lib\CMSIS\CM0\Core;..\inc;..\BSP\SPI;..\BSP\UART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Start
    ../../../../HK32F0301MxxC_Library/Lib/CMSIS/HK32F0301MxxC/Source/ARM/: KEIL_Startup_hk32f0301mxxc.s
  group src
    ../src/: main.c hk32f0301mxxc_it.c uart.c
    ../../../../HK32F0301MxxC_Library/Lib/CMSIS/HK32F0301MxxC/Source/: system_hk32f0301mxxc.c
  group HK32F030xMxxA_lib
    ../../../../HK32F0301MxxC_Library/Lib/HK32F0301MxxC_Lib/src/: hk32f0301mxxc_adc.c hk32f0301mxxc_awut.c hk32f0301mxxc_crc.c hk32f0301mxxc_dbgmcu.c hk32f0301mxxc_exti.c hk32f0301mxxc_flash.c hk32f0301mxxc_gpio.c hk32f0301mxxc_i2c.c hk32f0301mxxc_iwdg.c hk32f0301mxxc_misc.c hk32f0301mxxc_pwr.c hk32f0301mxxc_rcc.c hk32f0301mxxc_spi.c hk32f0301mxxc_syscfg.c hk32f0301mxxc_tim.c hk32f0301mxxc_uart.c hk32f0301mxxc_wwdg.c
