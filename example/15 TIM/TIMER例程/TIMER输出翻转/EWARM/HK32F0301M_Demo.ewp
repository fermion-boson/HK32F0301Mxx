# IAR project HK32F0301M_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HK32F0301MF4 HK HK32F0301MF4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: HK32F0301MF4P6; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\..\..\..\HK32F0301M\CMSIS\CM0\Core; ..\..\..\..\..\HK32F0301M\CMSIS\HK32F0301M\Source; ..\..\..\..\..\HK32F0301M\CMSIS\HK32F0301M\Include; ..\..\..\..\..\HK32F0301M\HK32F0301M_Lib\src; ..\..\..\..\..\HK32F0301M\HK32F0301M_Lib\inc; ..\..\..\..\..\..\..\HK32F030Mxx_ExampleV1.0.0\HK32F030Mxx_ExampleV1.0.2\project\15 TIM\TIMER例程\TIMER_PWM输入模式\src; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: HK32F0301M_Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../../HK32F0301M/CMSIS/HK32F0301M/Source/IAR/: IAR_Startup_hk32f0301m.s
    ../../../../../HK32F0301M/CMSIS/HK32F0301M/Source/: system_hk32f0301m.c
  group HK32F0301M_Lib
    ../../../../../HK32F0301M/HK32F0301M_Lib/src/: hk32f0301m_adc.c hk32f0301m_awu.c hk32f0301m_beep.c hk32f0301m_crc.c hk32f0301m_exti.c hk32f0301m_flash.c hk32f0301m_gpio.c hk32f0301m_i2c.c hk32f0301m_iwdg.c hk32f0301m_misc.c hk32f0301m_pwr.c hk32f0301m_rcc.c hk32f0301m_spi.c hk32f0301m_syscfg.c hk32f0301m_tim.c hk32f0301m_usart.c hk32f0301m_wwdg.c
  group User
    ../src/: hk32f0301m_it.c main.c
